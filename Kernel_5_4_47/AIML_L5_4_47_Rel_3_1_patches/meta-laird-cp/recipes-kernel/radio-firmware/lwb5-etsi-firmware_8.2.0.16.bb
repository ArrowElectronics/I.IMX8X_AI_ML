SUMMARY = "Laird Connectivity LWB5 Firmware for ETSI Regulatory Domain"

SRC_URI += "file://laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
