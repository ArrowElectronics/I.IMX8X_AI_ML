SUMMARY = "Laird Connectivity LWB5 Firmware for FCC Regulatory Domain"

SRC_URI += "file://laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
